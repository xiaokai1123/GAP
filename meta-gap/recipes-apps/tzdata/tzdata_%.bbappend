FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

DEFAULT_TIMEZONE = "Asia/Hong_Kong"
